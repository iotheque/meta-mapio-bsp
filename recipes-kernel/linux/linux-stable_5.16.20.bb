FILESEXTRAPATHS:prepend = "${THISDIR}/${PN}_${PV}/:"

require linux-stable.inc
