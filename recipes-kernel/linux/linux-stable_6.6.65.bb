SUMMARY = "Kernel Recipe"
DESCRIPTION = "Custom kernel recipe to build a mainline kernel"
HOMEPAGE = "https://github.com/iotheque/meta-mapio-bsp"
require linux-stable.inc
